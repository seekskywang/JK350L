# Keil uVision project Fire_uCOS.uvprojx, settings and files
target μCOS-III (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: μCOS-III +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F7xx_HAL_Driver\Inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView;..\..\User\BSP\lcd;..\..\User\BSP\fonts;..\..\User\H_FILE;..\..\User\APP;..\..\User\BSP\key;..\..\User\PAGE;..\..\User\RS;..\..\User\BSP\RTC;..\..\User\H_FILE;..\..\User\BSP\sdmmc;..\..\User\FATFS;..\..\User\FATFS\drivers;..\..\User\FATFS\option;..\..\User\BSP\beep;..\..\User\BSP\Common;..\..\User\BSP\ESP8266;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\User\BSP\USB;..\..\Middlewares\ModBus\ModBus;..\..\User\BSP\tim;..\..\User\BSP\CH367T;..\..\User\FILESYS;..\..\User\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
    ../../User/: stm32f7xx_hal_conf.h
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_spi_ex.c
  group USER_APP
    ../../User/APP/: main.c app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_app_hooks.c os_cfg_app.h os_app_hooks.h work.c dispdata.c rtc.c Flash.c QFlash.c bsp_bmp.c ICO.c
    ../../User/BSP/: cpu_bsp.c
    ../../User/: stm32f7xx_it.c
  group BSP
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/lcd/: bsp_lcd.c
    ../../User/BSP/sdram/: bsp_sdram.c
    ../../User/BSP/fonts/: font8.c font12.c font16.c font20.c font24.c fontLJ.c
    ../../User/BSP/flash/: bsp_qspi_flash.c
    ../../User/BSP/key/: bsp_key.c
    ../../User/BSP/usart/: bsp_rs232_usart.c
    ../../User/BSP/RTC/: bsp_rtc.c
    ../../User/BSP/sdmmc/: bsp_sdmmc_sd.c
    ../../User/BSP/beep/: bsp_beep.c
    ../../User/BSP/ESP8266/: bsp_esp8266.c
    ../../User/BSP/Common/: Common8266.c
    ../../User/BSP/tim/: bsp_basic_tim.c bsp_advance_tim.c
    ../../User/BSP/CH367T/: CHUSB.c CHUSB.h
  group μC/CPU
    ../../User/uC-CPU/Cache/ARM/armv7m_generic_l1/: cpu_cache_armv7m_generic_l1.c
    ../../User/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group μC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group μC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group μC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group DOC
    ../../Doc/: readme.txt
  group H_FILE
    ../../User/H_FILE/: include.h DataType.h
  group PAGE
    ../../User/PAGE/: homeData.c home.c common.c graph.c dispCh.c dispCh3.c homeOtur.c homeIF.c homefile.c record.c
    ../../User/APP/: Light.c power_on.c
  group RS
    ../../User/RS/: SLCZRF.C
  group FatFs
    ../../User/FATFS/: diskio.c ff.c ff_gen_drv.c sd_diskio.c
    ../../User/FATFS/option/: cc936.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group USB
    ../../User/BSP/USB/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
  group Modbus
    ../../Middlewares/ModBus/ModBus/: ModBus.c
  group FS
    ../../User/FILESYS/: FILESYSL.c FILESYSL.h
